options:
  parameters:
    generate_options: qt_gui
    id: practica1_b
    output_language: python
    title: configuracionUSAP
  states: {}

blocks:
- name: GX
  id: variable_qtgui_range
  parameters:
    label: ganacia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: a
  id: variable_qtgui_range
  parameters:
    label: amplitud señal TX
    start: '0'
    step: 100u
    stop: '1'
    value: 500m
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50M
    step: 1M
    stop: 2.2G
    value: 50M
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200k
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 500m
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: 200k
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
